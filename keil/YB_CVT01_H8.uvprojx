# Keil uVision project YB_CVT01_H8.uvprojx, settings and files
target YB_CVT01_H8 (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20200000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: YB_CVT01_H8 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c misc: -Wno-comment
  c include: C:\ti\mspm0_sdk_2_10_00_04\source\third_party\CMSIS\Core\Include;C:\ti\mspm0_sdk_2_10_00_04\source;..\BSP;..;..\APP;..\BSP\Motor;..\BSP\OLED;..\BSP\ultrasonic;..\BSP\kalman;..\BSP\mpu6050;..\BSP\eMPL;..\BSP\filter;..\BSP\control;..\BSP\task;..\BSP\flash;..\BSP\IR
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  link misc: C:\ti\mspm0_sdk_2_10_00_04\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group Source
    ../: empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c main.c
    ./: startup_mspm0g350x_h8_uvision.s
    ../BSP/: AllHeader.h config.h
  group BSP
    ../BSP/: bsp.c delay.c usart0.c usart1_ble.c magnet.c bsp_beep_led.c bsp_key.c bsp_RGB.c bsp_ir_receiver.c bsp_timer.c
    ../BSP/Motor/: bsp_motor.c bsp_encoder.c
    ../BSP/OLED/: oled.c
    ../BSP/flash/: bsp_flash_W25Q64.c
    ../BSP/ultrasonic/: bsp_ultrasonic.c
    ../BSP/kalman/: kalman.c kalman.h
    ../BSP/mpu6050/: bsp_mpu6050.c bsp_mpu6050.h get_mpu6050.c get_mpu6050.h
    ../BSP/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c dmpKey.h dmpmap.h inv_mpu.h inv_mpu_dmp_motion_driver.h
    ../BSP/filter/: Filter.c Filter.h
    ../BSP/control/: control.c control.h
    ../BSP/task/: task.c task.h
    ../BSP/IR/: bsp_ir.c bsp_ir.h
  group APP
    ../APP/: app_rgb.c app_irremote.c app_motor.c bsp_PID_motor.c app_irtracking_eight.c app_irtracking_eight.h
